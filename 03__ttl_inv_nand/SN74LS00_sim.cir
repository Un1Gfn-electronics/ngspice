.title SN74LS00_sim
.include SN74LS00.cir

V0 vc   0    5v
Rs vcc vc 5500ohm

Va a 0 5v
Vb b 0 5v

* Va a 0 5v
* Vb b 0 0v

* Va a 0 0v
* Vb b 0 5v

* Va a 0 0v
* Vb b 0 0v

XSN74LS00 y a b vcc 0 SN74LS00

.control
  * option trtol=7
  op
  print a b y
  * plot a b pointplot
.endc
