.title SN74LS00_sim
.include SN74LS00.cir

Vs s 0 5v
Va a 0 5v
Vb b 0 dc 0 PULSE(0v 5v 0s 10e-20s 10e-20s 1s 2s)

Rs s_ s 5500
Ry y  0 40k

XSN74LS00 y a b s_ 0 SN74LS00

.control
  tran 1ms 8s
  plot a
  plot b
  plot y
.endc
