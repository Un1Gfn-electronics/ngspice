* ngspice -b SN74LS00_sim.cir

.title SN74LS00_sim
.include SN74LS00.cir

Va a 0 0v
Vb b 0 0v

Vs s_ 0   5v
Rs s_ s   5k
* Ry y  0 900k

XSN74LS00 y a b s 0 SN74LS00

.control
  * set GMIN=1.0e-12
  * set GMINSTEPS=0
  set width=11 numdgt=3
  foreach aa 0 5v
    foreach bb 0 5v
      alter Va=$aa
      alter Vb=$bb
      op
      echo
      echo
      echo
      print a b y
      echo
      echo
      echo
      shell read -r
    end
  end
.endc
