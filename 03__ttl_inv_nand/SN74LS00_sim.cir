.title SN74LS00_sim
.include SN74LS00.cir

V0 s 0 5v
Va a 0 dc 0 PWL(0s 0v 1ns 5v)

Rs ss s 5k
Rb bb s 1m
Ra aa a 1m

Vb b 0 5v

XSN74LS00 yy aa bb ss 0 SN74LS00

Ry yy 0 10k

.control
  * option trtol=7
  * plot a b
  * set xtrtol=2 trtol=8
  * set GMIN=1.0e-30
  tran 7us 5ms
  plot a b
  * plot y
  * op
  * print a b y
.endc
